*Loading inverters definition
Xload_0 output load_0 vdd vss inv
Xload_1 output load_1 vdd vss inv
Xload_2 output load_2 vdd vss inv
Xload_3 output load_3 vdd vss inv
Xload_4 output load_4 vdd vss inv
Xload_5 output load_5 vdd vss inv
Xload_6 output load_6 vdd vss inv
Xload_7 output load_7 vdd vss inv
Xload_8 output load_8 vdd vss inv
Xload_9 output load_9 vdd vss inv
Xload_10 output load_10 vdd vss inv
Xload_11 output load_11 vdd vss inv
Xload_12 output load_12 vdd vss inv
Xload_13 output load_13 vdd vss inv
Xload_14 output load_14 vdd vss inv
Xload_15 output load_15 vdd vss inv
Xload_16 output load_16 vdd vss inv
Xload_17 output load_17 vdd vss inv
Xload_18 output load_18 vdd vss inv
Xload_19 output load_19 vdd vss inv
Xload_20 output load_20 vdd vss inv
Xload_21 output load_21 vdd vss inv
Xload_22 output load_22 vdd vss inv
Xload_23 output load_23 vdd vss inv
Xload_24 output load_24 vdd vss inv
Xload_25 output load_25 vdd vss inv
Xload_26 output load_26 vdd vss inv
Xload_27 output load_27 vdd vss inv
Xload_28 output load_28 vdd vss inv
Xload_29 output load_29 vdd vss inv
Xload_30 output load_30 vdd vss inv
Xload_31 output load_31 vdd vss inv

*Loading Capacitors
CLoad_0 load_0 vss C_unit
CLoad_1 load_1 vss C_unit
CLoad_2 load_2 vss C_unit
CLoad_3 load_3 vss C_unit
CLoad_4 load_4 vss C_unit
CLoad_5 load_5 vss C_unit
CLoad_6 load_6 vss C_unit
CLoad_7 load_7 vss C_unit
CLoad_8 load_8 vss C_unit
CLoad_9 load_9 vss C_unit
CLoad_10 load_10 vss C_unit
CLoad_11 load_11 vss C_unit
CLoad_12 load_12 vss C_unit
CLoad_13 load_13 vss C_unit
CLoad_14 load_14 vss C_unit
CLoad_15 load_15 vss C_unit
CLoad_16 load_16 vss C_unit
CLoad_17 load_17 vss C_unit
CLoad_18 load_18 vss C_unit
CLoad_19 load_19 vss C_unit
CLoad_20 load_20 vss C_unit
CLoad_21 load_21 vss C_unit
CLoad_22 load_22 vss C_unit
CLoad_23 load_23 vss C_unit
CLoad_24 load_24 vss C_unit
CLoad_25 load_25 vss C_unit
CLoad_26 load_26 vss C_unit
CLoad_27 load_27 vss C_unit
CLoad_28 load_28 vss C_unit
CLoad_29 load_29 vss C_unit
CLoad_30 load_30 vss C_unit
CLoad_31 load_31 vss C_unit
