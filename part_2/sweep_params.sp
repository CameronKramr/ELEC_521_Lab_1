.DATA sweep_params size_stage_1 size_stage_2 size_stage_3
1	2	3
2	3	4
.ENDDATA
