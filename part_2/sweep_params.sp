.DATA sweep_params size_stage_1 size_stage_2 size_stage_3
 1.0 1.0 1.00000001
.ENDDATA
