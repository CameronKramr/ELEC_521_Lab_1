.DATA sweep_params size_0 size_1 size_2
 1.8106475329900005 5.460792461825214 14.330560564228758
.ENDDATA
