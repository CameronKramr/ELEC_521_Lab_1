.DATA sweep_params size_stage_1 size_stage_2 size_stage_3
 2.0 4.0 8.000000014901161
.ENDDATA
